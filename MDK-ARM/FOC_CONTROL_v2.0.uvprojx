# Keil uVision project FOC_CONTROL_v2.0.uvprojx, settings and files
target FOC_CONTROL_v2.0 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: FOC_CONTROL_v2.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G431xx
  c include: ..\Core\Inc;..\USB_Device\App;..\USB_Device\Target;..\Drivers\STM32G4xx_HAL_Driver\Inc;..\Drivers\STM32G4xx_HAL_Driver\Inc\Legacy;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\Drivers\CMSIS\Include;.cmsis\include;RTE\_FOC_CONTROL_v2.0
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_ll_rcc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_ll_cordic.c stm32g4xx_hal_fdcan.c stm32g4xx_ll_fmac.c stm32g4xx_ll_i2c.c stm32g4xx_ll_opamp.c stm32g4xx_ll_spi.c stm32g4xx_ll_tim.c stm32g4xx_ll_usart.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c cordic.c fdcan.c fmac.c i2c.c opamp.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c oled.c motor_control.c pid.c remote_control.c s_curve.c can.c Sguan_NLFO.c smo.c foc.c nonlinear_flux_observer.c
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
software components: CMSIS:CORE 6.2.0
